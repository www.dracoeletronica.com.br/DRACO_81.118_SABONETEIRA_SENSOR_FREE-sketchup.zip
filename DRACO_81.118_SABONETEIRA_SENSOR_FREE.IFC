Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_81.118_SABONETEIRA_SENSOR_FREE.IFC
Time: 2022-12-21T17:22:26
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: CONEXÃO_PLF-6mm -G04_Default
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: DRACO_81.118-1_CHAPA_BASE_SABONETEIRA_SENSOR_FREE_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_81.118-3_EIXO_ROSCADO_SABONETEIRA_SENSOR_FREE_Default
In: Default Storey
Material: Brass

# IfcBuildingElementProxy: DRACO_81.118-3_RESERVATÓRIO_SABONETEIRA_SENSOR_FREE_Default
In: Default Storey
Material: PET

# IfcBuildingElementProxy: DRACO_81.118-4_SUPORTE_RESERVATÓRIO_SABONETEIRA_SENSOR_FREE_Default
In: Default Storey
Material: ABS

# IfcBuildingElementProxy: DRACO_81.118-4_TAMPA_ELETROVÁLVULA_SABONETEIRA_SENSOR_FREE_Default
In: Default Storey
Material: PA Type 6

# IfcBuildingElementProxy: DRACO_82.228-3_DISCO_INTERNO_Default
In: Default Storey
Material: Nylon 101

# IfcBuildingElementProxy: DRACO_82.228-6_CONTRA-PORCA_SEXTAVADA_Default
In: Default Storey
Material: AISI 1020

# IfcBuildingElementProxy: DRACO_82.228-9_SENSOR_INFRAVERMELHO_Default
In: Default Storey
Material: PVC 0.007 Plasticized
